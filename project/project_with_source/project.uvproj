# Keil uVision project project.uvproj, settings and files
target Project (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=9
  c include: ..\peripherials\inc;..\user
  group User
    ../user/: main.c isr.c
  group Peripherials
    ../peripherials/src/: btn.c led.c time.c tim.c exti.c display_seg.c pwm.c
