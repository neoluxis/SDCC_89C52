# Keil uVision project neolib51.uvproj, settings and files
target Lib_NeoLib51 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: neolib51 +hex (library)
  AfterMake: cp Objects/neolib51.LIB lib/neolib51.lib
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\peripherials\inc
  group library
    ../peripherials/src/: btn.c exti.c led.c tim.c
