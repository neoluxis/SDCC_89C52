# Keil uVision project project.uvproj, settings and files
target Project (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\peripherials\inc
  group User
    ../user/: main.c
  group NeoLib51
    ../neolib51/lib/: neolib51.lib
